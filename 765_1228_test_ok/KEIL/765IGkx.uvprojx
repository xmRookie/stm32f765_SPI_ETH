# Keil uVision project 765IGkx.uvprojx, settings and files
target 765IGkx (ARM-ADS)
  device: STM32F765IGKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: camera_dba +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F765xx
  c misc: --C99
  c include: ../include;../HAL/include;../HAL/include/Legacy;../core/include;C:\Keil_v5\ARM\ARMCC\include;../audio;../audio/libavcodec;../audio/libavcodec/libavcodec;../audio/libavutil;../audio/libavutil/libavutil;../audio/libavutil/arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group core
    ../core/: startup_stm32f765xx.s
  group driver
    ../driver/led/: led.c
    ../driver/romflash/: romflash.c
    ../driver/input/: key.c
    ../driver/dma/: dma.c
    ../driver/i2c/: i2c1.c i2c2.c i2c3.c i2c4.c
    ../driver/spi/: spi1.c spi4.c spi5.c spi_common.c
    ../driver/usart/: uart2.c uart4.c uart6.c uart3.c
    ../driver/i2s/: i2s2.c i2s3.c
  group app
    ../app/: main.c ethernetif.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c pollint.c udp_api.c eventManage.c power.c config_env.c mboot.c tsmux.c
  group HAL
    ../HAL/: stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2s.c
  group audio
    ../audio/: mp2.c
  group audio/libavcodec
    ../audio/libavcodec/: mpegaudio.c mpegaudiodata.c mpegaudioenc.c
  group audio/libavutil
    ../audio/libavutil/: log.c mathematics.c mem.c
